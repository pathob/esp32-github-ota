## sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_BAUD_921600B=y
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y

CONFIG_PARTITION_TABLE_TWO_OTA=y

CONFIG_ESP_HTTP_CLIENT_ENABLE_HTTPS=y
```
